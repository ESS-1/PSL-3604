# IAR project psl-3604.ewp, settings and files
configuration PSL-3604 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100C8 ST STM32F100C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; PSL3604
  ICCARM.CCIncludePath2: Source\Sys\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: psl-3604.hex
  ILINK.IlinkOutputFile: psl-3604.out
  ILINK.IlinkIcfFile: psl-3604.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PSL-3604_M1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD_VL; PSL3604_M1
  OBJCOPY.OOCOutputFile: psl-3604-m1.hex
  ILINK.IlinkOutputFile: psl-3604-m1.out
  group App
    Source/: analog.cpp control.cpp data.cpp display.cpp eeprom.cpp encoder.cpp fan.cpp i2csw.cpp keyboard.cpp main.cpp menu.cpp port.cpp sound.cpp sreg.cpp systimer.cpp therm.cpp wake.cpp wakeport.cpp
  group Sys
    Source/Sys/: startup_stm32f10x_md_vl.s stm32f10x.h
